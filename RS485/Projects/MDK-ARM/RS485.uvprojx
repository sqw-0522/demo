# Keil uVision project RS485.uvprojx, settings and files
target RS485 (6210000::V6.21::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RS485
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\..\User;..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\OLED;..\..\Drivers\BSP\RS485;..\..\Drivers\BSP\PY32F002Bxx_Start_Kit;..\..\Drivers\PY32F002B_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Startup
    ../../Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f002bxx.s
  group User
    ../../User/: py32f002b_it.c py32f002b_hal_msp.c system_py32f002b.c main.c
  group Drivers/BSP
    ../../Drivers/BSP/PY32F002Bxx_Start_Kit/: py32f002bxx_Start_Kit.c
    ../../Drivers/BSP/RS485/: rs485.c
    ../../Drivers/BSP/OLED/: OLED.c OLED_Data.c
    ../../Drivers/BSP/LED/: led.c
  group Drivers/PY32F002B_HAL_Driver
    ../../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_gpio.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c py32f002b_hal_cortex.c py32f002b_hal_i2c.c
